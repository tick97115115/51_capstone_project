# Keil uVision project project_template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project_template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\ds18b20;.\App\lcd1602;.\App\smg
  group Main
    ./: main.c
  group LCD1602
    ./App/lcd1602/: lcd1602.c lcd1602.h
  group DS18B20
    ./App/ds18b20/: ds18b20.c ds18b20.h
  group SMG
    ./App/smg/: smg.c smg.h
  group Public
    ./Public/: public.c public.h
